options:
  parameters:
    generate_options: qt_gui
    id: BFSKmod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '99970'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '47600'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '50'
  states: {}
- name: mult
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-51'
    step: '1'
    stop: '51'
    value: '0'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: (interp+2)*fsk_deviation_hz
    low_cutoff_freq: (interp-2)*fsk_deviation_hz
    samp_rate: samp_rate
    type: fir_filter_fff
    width: fsk_deviation_hz
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cusli/Documents/encoders/encoderV2/bitPipe
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2/interp'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.224'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interp
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: interp*bitrate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: fsk_deviation_hz*interp*2*pi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    tr_level: '-40'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '5000000'
    center_freq0: 433920000-mult*fsk_deviation_hz
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: radio
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: radio
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_f_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_sink_0, async_msgs, uhd_usrp_sink_0, command]
- [virtual_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
